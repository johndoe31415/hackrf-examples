options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: toycar_rx
    output_language: python
    title: Toy car RX with sniffing
  states: {}

blocks:
- name: frequency_ghz
  id: variable_qtgui_range
  parameters:
    label: Frequency (GHz)
    start: '2.420'
    step: '0.010'
    stop: '2.462'
    value: '2.433'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(3e6)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /tmp/toycar_rf.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    ant0: RX
    args: ''
    bb_gain0: '15'
    freq0: frequency_ghz*1e9
    gain0: '15'
    gain_mode0: 'True'
    if_gain0: '15'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '512'
    type: complex
  states: {}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [osmosdr_source_0_0, '0', blocks_complex_to_float_0, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_1, '0']
- [osmosdr_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
